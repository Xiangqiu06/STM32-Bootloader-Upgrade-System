# Keil uVision project demo1.uvprojx, settings and files
target demo1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: demo1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\stm32-bootloader-upgrade\bootloader;..\..\stm32-bootloader-upgrade\platform;..\..\stm32-bootloader-upgrade\common;..\..\stm32-bootloader-upgrade\application;..\..\stm32-bootloader-upgrade\platform;..\..\stm32-bootloader-upgrade\reset
  memory RVCT4: ROM 0x8006000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group boot
    ../../stm32-bootloader-upgrade/bootloader/: boot_jump.c boot_main.c
  group platform
    ../../stm32-bootloader-upgrade/platform/: bsp_at24c02.c bsp_flash.c bsp_uart_dma.c bsp_w25q64.c
  group common
    ../../stm32-bootloader-upgrade/common/: crc_utils.c fw_param.c fw_proto.c fw_update.c
  group app
    ../../stm32-bootloader-upgrade/application/: app_main.c
  group reset
    ../../stm32-bootloader-upgrade/reset/: reset_main.c
software components: CMSIS:CORE 5.6.0
